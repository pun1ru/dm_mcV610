# Keil uVision project dm_mcV610.uvprojx, settings and files
target dm_mcV610 (6190000::V6.19::ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: dm_mcV610 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32H723xx
  c include: ../Core/Inc;../LibSE/BSP/CAN;../LibSE/BSP/SPI;../LibSE/BSP/PWM;../LibSE/BSP/UART;../LibSE/BSP/DWT;../LibSE/Drivers/Buzzer;../LibSE/Drivers/WS2812;../LibSE/Drivers/Bmi088;../LibSE/Drivers/Referee;../LibSE/Drivers/RC/DT7;../LibSE/Drivers/RC/VT13;../LibSE/Drivers/UI;../LibSE/Drivers/Motor;../LibSE/Drivers/Motor/DMMotor;../LibSE/Drivers/Motor/LKMotor;../LibSE/Drivers/Motor/RMMotor;../LibSE/Algorithm/Math;../LibSE/Algorithm/Control/PID;../LibSE/Algorithm/Control/ADRC;../LibSE/Algorithm/Process/kalman_filter;../LibSE/Algorithm/Process/ekf;../LibSE/Algorithm/INS/Madgwick;../LibSE/Algorithm/Kinematics;../LibSE/Module/INS;../LibSE/Module/Gimbal;../LibSE/Module/Monitor;../LibSE/minimal_state;../App;../App/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group LibSE/Algorithm/Control/ADRC
    ../LibSE/Algorithm/Control/ADRC/: adrc.c adrc.h
  group LibSE/Algorithm/Control/PID
    ../LibSE/Algorithm/Control/PID/: pid.c pid.h
  group LibSE/Algorithm/INS/Madgwick
    ../LibSE/Algorithm/INS/Madgwick/: Madgwick.c Madgwick.h
  group LibSE/Algorithm/Kinematics
    ../LibSE/Algorithm/Kinematics/: dh.c dh.h
  group LibSE/Algorithm/Math
    ../LibSE/Algorithm/Math/: algorism.c algorism.h arm_matrix.h
  group LibSE/Algorithm/Process/ekf
    ../LibSE/Algorithm/Process/ekf/: ekf_quaternion.c ekf_quaternion.h
  group LibSE/Algorithm/Process/kalman_filter
    ../LibSE/Algorithm/Process/kalman_filter/: kalman_filter.c kalman_filter.h
  group LibSE/BSP/CAN
    ../LibSE/BSP/CAN/: CAN_driver.c CAN_driver.h
  group LibSE/BSP/DWT
    ../LibSE/BSP/DWT/: bsp_dwt.c bsp_dwt.h
  group LibSE/BSP/PWM
    ../LibSE/BSP/PWM/: bsp_pwm.c bsp_pwm.h
  group LibSE/BSP/SPI
    ../LibSE/BSP/SPI/: bsp_spi.h
  group Application/Core
    ../Core/Src/: gpio.c adc.c dma.c fdcan.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
    ../Core/Inc/: adc.h dma.h fdcan.h gpio.h spi.h stm32h7xx_hal_conf.h stm32h7xx_it.h tim.h usart.h
  group LibSE/BSP/UART
    ../LibSE/BSP/UART/: uart_driver.c uart_driver.h vofa_justfloat.c vofa_justfloat.h vofa_uart.c vofa_uart.h
  group Application/USB_Device
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
    ../USB_DEVICE/Target/: usbd_conf.c
  group Application/USB_Device/Headers
    ../USB_DEVICE/App/: usb_device.h usbd_cdc_if.h usbd_desc.h
  group Application/USB_Device/Target
    ../USB_DEVICE/Target/: usbd_conf.h
  group LibSE/Drivers/Bmi088
    ../LibSE/Drivers/Bmi088/: bmi088_driver.c bmi088_middleware.c imu_temp_ctrl.c bmi088_driver.h bmi088_middleware.h bmi088_reg.h
  group LibSE/Drivers/Buzzer
    ../LibSE/Drivers/Buzzer/: bsp_buzzer.c bsp_buzzer.h
  group Application/System
    ../Core/Src/: system_stm32h7xx.c
  group ThirdParty/CMSIS/Core
    ../Drivers/CMSIS/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h
  group ThirdParty/CMSIS/Device
    ../Drivers/CMSIS/Device/ST/STM32H7xx/Include/: stm32h723xx.h stm32h7xx.h system_stm32h7xx.h
  group ThirdParty/CMSIS/Startup
    ./: startup_stm32h723xx.s
  group ThirdParty/FreeRTOS/Source
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group ThirdParty/FreeRTOS/CMSIS_RTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.h
  group ThirdParty/FreeRTOS/Include
    ../Middlewares/Third_Party/FreeRTOS/Source/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group LibSE/Drivers/Motor
    ../LibSE/Drivers/Motor/: Motor.c Motor.h
  group LibSE/Drivers/Motor/DMMotor
    ../LibSE/Drivers/Motor/DMMotor/: DMMotor.c DMMotor.h
  group LibSE/Drivers/Motor/LKMotor
    ../LibSE/Drivers/Motor/LKMotor/: LKMotor.c LKMotor.h
  group LibSE/Drivers/Motor/RMMotor
    ../LibSE/Drivers/Motor/RMMotor/: RMMotor.c RMMotor.h
  group LibSE/Drivers/RC/DT7
    ../LibSE/Drivers/RC/DT7/: dt7_remote_driver.c remote_control.c dt7_remote_driver.h remote_control.h
  group LibSE/Drivers/RC/VT13
    ../LibSE/Drivers/RC/VT13/: CRC.c VT13_rc_ctrl.c VT13_rc_ctrl.h
  group LibSE/Drivers/Referee
    ../LibSE/Drivers/Referee/: judge_receive.c referee.c judge_receive.h referee.h
  group ThirdParty/STM32H7xx_HAL_Driver/Source
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group ThirdParty/STM32H7xx_HAL_Driver/Include
    ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
    ../Drivers/STM32H7xx_HAL_Driver/Inc/: stm32h7xx_hal.h stm32h7xx_hal_adc.h stm32h7xx_hal_adc_ex.h stm32h7xx_hal_cortex.h stm32h7xx_hal_def.h stm32h7xx_hal_dma.h stm32h7xx_hal_dma_ex.h stm32h7xx_hal_exti.h stm32h7xx_hal_fdcan.h stm32h7xx_hal_flash.h stm32h7xx_hal_flash_ex.h stm32h7xx_hal_gpio.h stm32h7xx_hal_gpio_ex.h stm32h7xx_hal_hsem.h stm32h7xx_hal_i2c.h stm32h7xx_hal_i2c_ex.h stm32h7xx_hal_mdma.h stm32h7xx_hal_pcd.h stm32h7xx_hal_pcd_ex.h stm32h7xx_hal_pwr.h stm32h7xx_hal_pwr_ex.h stm32h7xx_hal_rcc.h stm32h7xx_hal_rcc_ex.h stm32h7xx_hal_spi.h stm32h7xx_hal_spi_ex.h stm32h7xx_hal_tim.h stm32h7xx_hal_tim_ex.h stm32h7xx_hal_uart.h stm32h7xx_hal_uart_ex.h stm32h7xx_ll_adc.h stm32h7xx_ll_bus.h stm32h7xx_ll_cortex.h stm32h7xx_ll_crs.h stm32h7xx_ll_dma.h stm32h7xx_ll_dmamux.h stm32h7xx_ll_exti.h stm32h7xx_ll_gpio.h stm32h7xx_ll_hsem.h stm32h7xx_ll_lpuart.h stm32h7xx_ll_pwr.h stm32h7xx_ll_rcc.h stm32h7xx_ll_spi.h stm32h7xx_ll_system.h stm32h7xx_ll_tim.h stm32h7xx_ll_usart.h stm32h7xx_ll_usb.h stm32h7xx_ll_utils.h
  group LibSE/Drivers/UI
    ../LibSE/Drivers/UI/: UI_driver.h
  group ThirdParty/USB_Device_Library/Source
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group ThirdParty/USB_Device_Library/CDC
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc/: usbd_cdc.h
  group ThirdParty/USB_Device_Library/Core
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc/: usbd_core.h usbd_ctlreq.h usbd_def.h usbd_ioreq.h
  group LibSE/Drivers/WS2812
    ../LibSE/Drivers/WS2812/: ws2812_board.c WS2812.h
  group LibSE/Module/INS
    ../LibSE/Module/INS/: ins.c ins.h
  group LibSE/Module/Gimbal
    ../LibSE/Module/Gimbal/: gimbal.c gimbal.h
  group LibSE/Module/Monitor
    ../LibSE/Module/Monitor/: monitor.c monitor.h
  group LibSE/minimal_state
    ../LibSE/minimal_state/: gimbal_ammo_state.c gimbal_ammo_state.h
  group App/Task
    ../App/Src/: task_ins.c task_gimbal.c task_receive.c task_transmit.c task_monitor.c task_state.c
    ../App/Inc/: task_gimbal.h task_ins.h task_monitor.h task_receive.h task_transmit.h task_state.h
  group Application/Core/Startup
    ../Core/Src/: main.c
    ../Core/Inc/: main.h
  group Application/FreeRTOS
    ../Core/Src/: freertos.c
    ../Core/Inc/: FreeRTOSConfig.h
  group App/System
    ../App/: task_init.c base_init.c ipc_init.c comm_init.c module_init.c task_system.c task_init.h base_init.h ipc_init.h comm_init.h module_init.h task_define.h task_system.h
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c fdcan.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.16.2
